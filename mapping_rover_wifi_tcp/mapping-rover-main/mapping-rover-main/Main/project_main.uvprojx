# Keil uVision project project_main.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project_main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\core;.\platform;.\Lidar_bridge;.\Wifi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group
    ./: main.c
  group Servo
    ./servo/: servo.h servo.c
  group Lidar
    ./core/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h
    ./platform/: vl53l0x_i2c_platform.c vl53l0x_i2c_platform.h vl53l0x_i2c_win_serial_comms.c vl53l0x_platform.c vl53l0x_platform.h vl53l0x_platform_log.c vl53l0x_platform_log.h vl53l0x_types.h
    ./Lidar_bridge/: my_platform.h my_platfrom.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.4.2
